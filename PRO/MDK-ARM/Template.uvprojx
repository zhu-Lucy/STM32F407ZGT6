# Keil uVision project Template.uvprojx, settings and files
target STM32F4 Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Core;..\..\STM32F4xx_FWLIB\inc;..\..\USER;..\..\DeviceDriver\led;..\..\Common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Core
    ../../Core/: startup_stm32f40_41xxx.s
  group STM32F10x_FWLib
    ../../STM32F4xx_FWLIB/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c
  group DeviceDriver
    ../../DeviceDriver/led/: led.c
